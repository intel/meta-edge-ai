SRC_URI[k3s.sha256sum] = "e81a9ee17e87a54197c30af761dc6f84bce7e4fece7382900c075670f3f73e3d"
K3S_VERSION="1.18.4+k3s1"

export GOCACHE = "${B}/.cache"